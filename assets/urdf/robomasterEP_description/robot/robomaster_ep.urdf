Commit message: delete something worthless

File: assets/urdf/robomasterEP_description/robot/robomaster_ep.urdf (robot description, URDF)
Before this commit: robot robomaster_ep, 39 links, 38 joints
Links:
- link base_link: mass 0.001 -> None
